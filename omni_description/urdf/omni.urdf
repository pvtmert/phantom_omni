Commit message: Custom driver without lock+

File: omni_description/urdf/omni.urdf (robot description, URDF)
Before this commit: robot phantom_omni, 7 links, 6 joints
Joints:
- joint roll: axis 0 1 0 -> 0 -1 0
